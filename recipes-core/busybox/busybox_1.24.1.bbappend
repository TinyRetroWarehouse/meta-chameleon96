FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://lscolor-busybox-1.24.1.cfg"
